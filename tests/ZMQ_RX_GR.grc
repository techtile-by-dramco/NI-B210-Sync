options:
  parameters:
    generate_options: qt_gui
    id: ZMQ_RX_GR
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://localhost:8888
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [zeromq_pull_source_0, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
