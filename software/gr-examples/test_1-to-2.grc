options:
  parameters:
    generate_options: qt_gui
    id: test_1_to_2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: f_tx
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: fc
  id: variable
  parameters:
    value: 400e6
  states: {}
- name: gain_rx
  id: variable
  parameters:
    value: '0.7'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e3
  states: {}
- name: samp_rate_rx
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0_1
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '4'
    size: int(samp_rate_rx/f_tx)*5
    srate: samp_rate_rx
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '2'
    size: int(samp_rate_rx/f_tx)*5
    srate: samp_rate_rx
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc+f_tx
    clock_source0: external
    dev_addr: '"serial=31DEAD2"'
    gain0: '0.5'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: pc_clock
    time_source0: external
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: fc
    center_freq1: fc
    clock_source0: external
    dev_addr: '"serial=31E2BD7"'
    gain0: gain_rx
    gain1: gain_rx
    gain_type0: normalized
    gain_type1: normalized
    nchan: '2'
    rx_agc0: Disabled
    rx_agc1: Disabled
    samp_rate: samp_rate_rx
    sync: pc_clock
    time_source0: external
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: fc
    center_freq1: fc
    clock_source0: external
    dev_addr: '"serial=31E2C39"'
    gain0: gain_rx
    gain1: gain_rx
    gain_type0: normalized
    gain_type1: normalized
    nchan: '2'
    rx_agc0: Disabled
    rx_agc1: Disabled
    samp_rate: samp_rate_rx
    sync: pc_clock
    time_source0: external
    type: fc32
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', qtgui_time_sink_x_1, '0']
- [analog_const_source_x_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_complex_to_real_0_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_complex_to_real_0_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_complex_to_real_0_1, '0', qtgui_time_sink_x_0, '2']
- [blocks_complex_to_real_0_1, '0', qtgui_time_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_real_0_1, '0']
- [uhd_usrp_source_0, '1', blocks_complex_to_real_0_0_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_complex_to_real_0, '0']
- [uhd_usrp_source_0_0, '1', blocks_complex_to_real_0_0, '0']

metadata:
  file_format: 1
