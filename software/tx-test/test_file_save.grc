options:
  parameters:
    author: techtile
    generate_options: qt_gui
    id: test_file_save
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: 1024*6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/techtile/NI-B210-Sync/software/build/usrp_samples_31E2BD7_0.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/techtile/NI-B210-Sync/software/build/usrp_samples_31E2BD7_1.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/techtile/NI-B210-Sync/software/build/usrp_samples_31E2C39_0.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/techtile/NI-B210-Sync/software/build/usrp_samples_31E2C39_1.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: fft_len
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_len)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_len)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_len)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 2e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 2e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_abs_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', blocks_abs_xx_0, '0']
- [blocks_complex_to_real_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_real_0_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_complex_to_real_0_0_0_0, '0', qtgui_time_sink_x_0_0, '3']
- [blocks_complex_to_real_0_0_1, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_file_source_0, '0', low_pass_filter_0, '0']
- [blocks_file_source_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_file_source_0_0_0, '0', low_pass_filter_0_0_0, '0']
- [blocks_file_source_0_0_0_0, '0', low_pass_filter_0_0_1, '0']
- [blocks_multiply_xx_0, '0', fft_vxx_0_1, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_real_0, '0']
- [fft_vxx_0, '0', blocks_multiply_xx_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_xx_0, '1']
- [fft_vxx_0_1, '0', blocks_vector_to_stream_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_real_0_0, '0']
- [low_pass_filter_0, '0', blocks_stream_to_vector_0, '0']
- [low_pass_filter_0_0, '0', blocks_complex_to_real_0_0_0, '0']
- [low_pass_filter_0_0_0, '0', blocks_complex_to_real_0_0_1, '0']
- [low_pass_filter_0_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [low_pass_filter_0_0_1, '0', blocks_complex_to_real_0_0_0_0, '0']

metadata:
  file_format: 1
