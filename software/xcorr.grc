options:
  parameters:
    generate_options: hb
    id: xcorr
    output_language: python
    title: Cross-correlator
  states: {}

blocks:
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: fft_len
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1.0/fft_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: fft_len
  id: parameter
  parameters:
    label: fft_len
    type: intx
    value: '1024'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in_0
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in_1
    type: complex
  states: {}

connections:
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_0_1, '0']
- [blocks_multiply_const_xx_0, '0', pad_sink_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_multiply_const_xx_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_0_1, '0', blocks_vector_to_stream_0_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0_0, '0']
- [pad_source_0_0, '0', blocks_stream_to_vector_0_0_0, '0']

metadata:
  file_format: 1
