options:
  parameters:
    author: techtile
    generate_options: qt_gui
    id: xcorr_files
    output_language: python
    title: xcorr files
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: seq_len*2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: seq_len
  id: variable
  parameters:
    value: '353'
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/techtile/NI-B210-Sync/software/rx-test/rx-zc/build/usrp_samples_31E2BD7_0.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/techtile/NI-B210-Sync/software/rx-test/rx-zc/build/usrp_samples_31E2BD7_1.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/techtile/NI-B210-Sync/software/rx-test/rx-zc/build/usrp_samples_31E2C39_0.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/techtile/NI-B210-Sync/software/rx-test/rx-zc/build/usrp_samples_31E2C39_1.dat
    repeat: 'False'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (0,0)
    name: '"USRP1"'
    size: seq_len
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (3,0)
    name: '"USRP1 vs USRP2"'
    size: seq_len
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: (1,0)
    name: '"USRP2"'
    size: seq_len
    srate: samp_rate
    type: float
  states: {}
- name: xcorr_0
  id: xcorr
  parameters:
    fft_len: fft_len
  states: {}
- name: xcorr_0_0
  id: xcorr
  parameters:
    fft_len: fft_len
  states: {}
- name: xcorr_0_1
  id: xcorr
  parameters:
    fft_len: fft_len
  states: {}

connections:
- [blocks_complex_to_mag_1, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_complex_to_mag_1_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [blocks_complex_to_mag_1_1, '0', qtgui_time_sink_x_0_0_0_0_1, '0']
- [blocks_file_source_0, '0', xcorr_0, '0']
- [blocks_file_source_0_0, '0', xcorr_0, '1']
- [blocks_file_source_0_0, '0', xcorr_0_0, '1']
- [blocks_file_source_0_0_0, '0', xcorr_0_0, '0']
- [blocks_file_source_0_0_0, '0', xcorr_0_1, '0']
- [blocks_file_source_0_0_0_0, '0', xcorr_0_1, '1']
- [xcorr_0, '0', blocks_complex_to_mag_1, '0']
- [xcorr_0_0, '0', blocks_complex_to_mag_1_0, '0']
- [xcorr_0_1, '0', blocks_complex_to_mag_1_1, '0']

metadata:
  file_format: 1
