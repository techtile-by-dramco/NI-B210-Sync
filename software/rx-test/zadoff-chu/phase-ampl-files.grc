options:
  parameters:
    author: techtile
    generate_options: qt_gui
    id: xcorr_files
    output_language: python
    title: xcorr files
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: seq_len*2
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: seq
  id: variable
  parameters:
    value: ZC.generate(7,seq_len)
  states: {}
- name: seq_len
  id: variable
  parameters:
    value: '353'
  states: {}
- name: ZC
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      import numpy as np

      def generate(u=1, seq_length=53, q=0):

          """
          Generate a Zadoff-Chu (ZC) sequence.
          Parameters
          ----------
          u : int
              Root index of the the ZC sequence: u>0.
          seq_length : int
              Length of the sequence to be generated. Usually a prime number:
              u<seq_length, greatest-common-denominator(u,seq_length)=1.
          q : int
              Cyclic shift of the sequence (default 0).
          Returns
          -------
          zcseq : 1D ndarray of complex floats
              ZC sequence generated.
              
         To still put DC to 0, 
         we interleave the ZC sequence with zeros.
       
          """
          
          for el in [u,seq_length,q]:
              if not float(el).is_integer():
                  raise ValueError('{} is not an integer'.format(el))
          if u<=0:
              raise ValueError('u is not stricly positive')
          if u>=seq_length:
              raise ValueError('u is not stricly smaller than seq_length')
              
          if np.gcd(u,seq_length)!=1:
              raise ValueError('the greatest common denominator of u and seq_length is not 1')
              

          cf = seq_length%2
          n = np.arange(seq_length)
          zcseq = np.exp( -1j * np.pi * u * n * (n+cf+2.0*q) / seq_length)
          
          return zcseq
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_arg_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/techtile/NI-B210-Sync/software/rx-test/zadoff-chu/RX/usrp_samples_31E2BD7_0.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/techtile/NI-B210-Sync/software/rx-test/zadoff-chu/RX/usrp_samples_31E2BD7_1.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/techtile/NI-B210-Sync/software/rx-test/zadoff-chu/RX/usrp_samples_31E2C39_0.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/techtile/NI-B210-Sync/software/rx-test/zadoff-chu/RX/usrp_samples_31E2C39_1.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,0)
    name: '"USRP1"'
    size: seq_len
    srate: samp_rate
    type: float
    ymax: '6.14'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,1)
    name: '"USRP2"'
    size: seq_len
    srate: samp_rate
    type: float
    ymax: '6.14'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: (0,2)
    name: '"USRP1 vs 2"'
    size: seq_len
    srate: samp_rate
    type: float
    ymax: '6.14'
    ymin: '0'
  states: {}

connections:
- [blocks_abs_xx_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_abs_xx_0_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [blocks_abs_xx_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '0']
- [blocks_complex_to_arg_0_0_0, '0', blocks_abs_xx_0, '0']
- [blocks_complex_to_arg_0_0_0_0, '0', blocks_abs_xx_0_0, '0']
- [blocks_complex_to_arg_0_0_0_0_0, '0', blocks_abs_xx_0_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_throttle_0_1, '0']
- [blocks_file_source_0_0_0_0, '0', blocks_throttle_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_arg_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', blocks_complex_to_arg_0_0_0_0, '0']
- [blocks_multiply_conjugate_cc_0_0_0, '0', blocks_complex_to_arg_0_0_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_throttle_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_throttle_0_0, '0', blocks_multiply_conjugate_cc_0_0_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [blocks_throttle_0_1, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [blocks_throttle_0_1, '0', blocks_multiply_conjugate_cc_0_0_0, '1']

metadata:
  file_format: 1
